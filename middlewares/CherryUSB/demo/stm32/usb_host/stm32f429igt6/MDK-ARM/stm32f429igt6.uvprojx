# Keil uVision project stm32f429igt6.uvprojx, settings and files
target stm32f429igt6 (6160000::V6.16::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f429igt6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../../../../common;../../../../../core;../../../../../class/cdc;../../../../../class/hub;../../../../../class/hid;../../../../../class/msc;../../../../../class/wireless;../../../../../class/video;../../../../../osal;../../../../../third_party/FreeRTOS-10.4/include;../../../../../third_party/FreeRTOS-10.4/portable/GCC/ARM_CM4F;../../../../../third_party/fatfs-0.14/source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Inc/: FreeRTOSConfig.h
    ../../../../: usb_host.c
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group FreeRTOS
    ../../../../../third_party/FreeRTOS-10.4/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/FreeRTOS-10.4/portable/MemMang/: heap_4.c
    ../../../../../third_party/FreeRTOS-10.4/portable/GCC/ARM_CM4F/: port.c
  group CherryUSB
    ../../../../../core/: usbh_core.c
    ../../../../../class/hub/: usbh_hub.c
    ../../../../../class/cdc/: usbh_cdc_acm.c
    ../../../../../class/msc/: usbh_msc.c
    ../../../../../class/hid/: usbh_hid.c
    ../../../../../class/wireless/: usbh_rndis.c
    ../../../../../class/video/: usbh_video.c
    ../../../../../osal/: usb_osal_freertos.c
    ../../../../../port/dwc2/: usb_hc_dwc2.c
  group fatfs
    ../../../../../third_party/fatfs-0.14/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../../../third_party/fatfs-0.14/source/port/: fatfs_usbh.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 5.4.0
